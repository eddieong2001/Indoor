# Keil uVision project Indoor_F030RC_Peripheral_Check_0.uvprojx, settings and files
target Indoor_F030RC_Peripheral_Check_0 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F030RC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Indoor_F030RC_Peripheral_Check_0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030xC
  c include: ../Inc;               ../Drivers/STM32F0xx_HAL_Driver/Inc;               ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;               ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;               ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32f030xc.s
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_tim.c stm32f0xx_hal_dma.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_adc.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_flash.c stm32f0xx_hal_uart.c stm32f0xx_hal_i2c.c stm32f0xx_hal_pwr.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f0xx.c
  group Application/User
    ../Src/: main.c stm32f0xx_hal_msp.c stm32f0xx_it.c led.c ir.c temperature.c comm_inout.c fan_ctrl.c step_ctrl.c
software components: CMSIS:CORE 4.3.0
